Commit message: Update anymal_lidar_imu.urdf

File: anymal_b_base/config/urdf/anymal_lidar_imu.urdf (robot description, URDF)
Before this commit: robot anymal, 23 links, 22 joints
Links:
- link base_inertia: mass 16.793507758 -> 5.0
